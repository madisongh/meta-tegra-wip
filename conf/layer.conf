## conf/layer.conf
```bitbake
LAYERNAME = "meta-tegra"
LAYERDEPENDS = "oe-core"
LAYERSERIES_COMPAT = "garburn"
addpylib ${LAYERDIR}/lib oe4t
```
